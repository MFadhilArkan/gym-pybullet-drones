Commit message: change _computeReward

File: gym_pybullet_drones/assets/ardrone2.urdf (robot description, URDF)
Before this commit: robot ardrone2, 6 links, 5 joints
Links:
- link base_link: geometry collision cylinder length=.02 radius=.22; visual mesh filename=./cf2.dae scale=1 1 1
